options:
  parameters:
    author: yango
    generate_options: qt_gui
    id: strobeBlock
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: complex
  states: {}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("strobe")
    nsamps: '100'
    type: complex
    value: pmt.intern("TEST")
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '30'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_tags_strobe_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
