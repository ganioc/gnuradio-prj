options:
  parameters:
    generate_options: qt_gui
    id: samprateBlock
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate/2'
    step: '10'
    stop: samp_rate/2
    value: '0'
  states: {}
- name: interpolation_rate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: lowPassTaps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate_interpolated/(interpolation_rate*2)
    gain: '1.0'
    samp_rate: samp_rate_interpolated
    width: samp_rate_interpolated/(interpolation_rate*4)
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_interpolated
  id: variable
  parameters:
    value: samp_rate*interpolation_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_interpolated
    type: complex
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: |-
      Input Samp Rate: 32KHz
      Output Samp Rate: 128KHz
    interp: interpolation_rate
    taps: lowPassTaps
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_interpolated
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
